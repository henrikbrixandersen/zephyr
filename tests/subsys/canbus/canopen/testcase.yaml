## tests/subsys/canbus/canopen/testcase.yaml
```yaml
tests:
  can.canopen:
    integration_platforms:
      - native_sim
      - native_sim/native/64
    tags:
      - can
```
